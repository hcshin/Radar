<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>USRPSampRate</value></param>
<param><key>value</key><value>base_samp_rate*100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rfFreq</value></param>
<param><key>value</key><value>5e9</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>USRP_radar_receiver_proto_dpsk</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>receiveUSRP</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=192.168.30.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>USRPSampRate</value></param>
<param><key>center_freq0</key><value>rfFreq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>digital_dxpsk_demod</key>
<param><key>id</key><value>dbpsk_demod</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>samples_per_symbol</key><value>10</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sync_out</key><value>False</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>unpacked_to_packed</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>hocheol_byte_decim_bb</key>
<param><key>id</key><value>byte_decimation</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>rcvd_code.byte</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>unpacked_to_packed</source_block_id><sink_block_id>byte_decimation</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receiveUSRP</source_block_id><sink_block_id>rational_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler</source_block_id><sink_block_id>dbpsk_demod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dbpsk_demod</source_block_id><sink_block_id>unpacked_to_packed</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>byte_decimation</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
